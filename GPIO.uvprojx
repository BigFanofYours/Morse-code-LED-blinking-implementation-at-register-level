# Keil uVision project GPIO.uvprojx, settings and files
target Target_1 (6240000::V6.24::ARMCLANG)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: GPIO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: GPIO.c main.c Delay.c system_stm32f4xx.c startup_stm32f407xx.s USART.c RCC.c
  group New Group
    ./: RCC_Register.h GPIO_Registers.h GPIO.h Delay.h USART_Registers.h USART.h RCC.h
